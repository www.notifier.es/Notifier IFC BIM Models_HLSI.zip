Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:37:35
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:37:35 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{7EA67053-00A3-4377-BDFF-EE7E41B6E1F6}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:37:34 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:37:35 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:37:35 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Address: Enter address here; Project Status: Project Status; Client Name: Owner; Project Name: Project Name; Project Issue Date: Issue Date; Project Number: Project Number

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Graphics - Line Pattern: Centre; Symbol at End 1 Default: no; Line Weight: 1; Symbol: Level Head - FFL: Level Head - FFL; Symbol at End 2 Default: yes; Color: 0
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Identity Data - Name: Level 2; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywelll Opal Addressable Wall Beacon NFXI-WF-WC, NFXI-WF-WC:Notifier by Honeywelll Opal Addressable Wall Beacon NFXI-WF-WC:207246
In: Level 2
Material: UHMW, White
Constraints - Host: Level : Level 2; Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 2
Identity Data - Mark: 5; Type Comments: Opal Addressable Wall Beacon; Product Code: NFXI-WF-WC; OmniClass Number: 23.85.30.21; Assembly Description: Misc. Other Fire Protection Systems; Description: Addressable Wall Sounder / Beacon; URL: www.notifierfiresystems.co.uk; Model: Wall Mounted Beacon; OmniClass Title: Environmental Detection/Registration; Assembly Code: D4090900; Manufacturer: Notifier by Honeywell
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywelll Opal Addressable Wall Beacon NFXI-WF-WC
Title Text - Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY, UK; Tel No.: +44 (0) 1273 897000; Fax No.: +44 (0) 1273 376894; Email: sales@notifierfiresystems.co.uk

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Dimensions - Area: 64.26 m2; Perimeter: 33000 mm
Constraints - Height Offset From Level: 2600 mm; Level: Level: Level 2; Room Bounding: yes
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Absorptance: 0.1; Roughness: 1
