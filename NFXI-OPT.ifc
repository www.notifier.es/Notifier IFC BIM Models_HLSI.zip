Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:40:46
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:40:46 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{B46AA937-96AF-486C-BBA2-5A44FC4ADD94}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:40:45 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:40:46 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:40:46 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Name: Project Name; Project Number: Project Number; Client Name: Owner; Project Status: Project Status; Project Address: Enter address here; Project Issue Date: Issue Date

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Graphics - Line Pattern: Centre; Line Weight: 1; Symbol at End 2 Default: yes; Symbol: Level Head - FFL: Level Head - FFL; Color: 0; Symbol at End 1 Default: no
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 2; Building Story: yes; Structural: no

# IfcBuildingElementProxy: Notifier by Honeywell OPAL Photoelectric Smoke Detector NFXI-OPT, NFX-OPT:Notifier by Honeywell OPAL Photoelectric Smoke Detector NFXI-OPT:209759
In: Level 2
Material: ALARM
Constraints - Offset: 0 mm; Moves With Nearby Elements: no; Host: Level : Level 2; Level: Level: Level 2
Identity Data - Mark: 8; Assembly Code: D4090900; OmniClass Title: Environmental Detection/Registration; Manufacturer: Notifier by Honeywell; URL: www.notifierfiresystems.co.uk; Description: Photoelectric Smoke Detector; Assembly Description: Misc. Other Fire Protection Systems; Model: OPAL Optical Smoke Detector; OmniClass Number: 23.85.30.21; Product Code: NFXI-OPT
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell OPAL Photoelectric Smoke Detector NFXI-OPT
Title Text - Tel No.: +44 (0) 1273 897000; Fax No.: +44 (0) 1273 376894; Email: sales@notifierefiresystems.co.uk; Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Dimensions - Perimeter: 33000 mm; Area: 64.26 m2
Constraints - Level: Level: Level 2; Room Bounding: yes; Height Offset From Level: 2600 mm
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Roughness: 1; Absorptance: 0.1
