Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:35:07
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:35:07 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{36AFC6E3-1508-4DA0-8E15-A42D540B5BC5}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:35:05 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:35:06 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:35:06 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Issue Date: Issue Date; Project Status: Project Status; Project Name: Project Name; Client Name: Owner; Project Address: Enter address here; Project Number: Project Number

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - FFL: Level Head - FFL; Symbol at End 2 Default: yes; Symbol at End 1 Default: no
Identity Data - Structural: no; Building Story: yes; Name: Level 2
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell OPAL SMART3 Photo,Thermal & Infra Red Multi-Criteria Detector NFXI-SMT3, NFXI-SMT3:Notifier by Honeywell OPAL SMART3 Photo,Thermal & Infra Red Multi-Criteria Detector NFXI-SMT3:205544
In: Level 2
Material: ALARM
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Host: Level : Level 2; Moves With Nearby Elements: no; Level: Level: Level 2
Identity Data - Mark: 3; URL: www.notifierfiresystems.co.uk; Manufacturer: Notifier by Honeywell; Assembly Code: D4090900; Description: Photoelectric, Thermal & Infra Red Multi-Criteria Detector; OmniClass Number: 23.85.30.21; Assembly Description: Misc. Other Fire Protection Systems; Product Code: NFXI-SMT3; OmniClass Title: Environmental Detection/Registration; Model: OPAL SMART3 Photo, Thermal & Infra Red Multi-Criteria Detector
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell OPAL SMART3 Photo,Thermal & Infra Red Multi-Criteria Detector NFXI-SMT3
Title Text - Fax No.: +44 (0) 1273 376894; Tel No.: +44 (0) 1273 897000; Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY; Email: sales@notifierefiresystems.co.uk

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Constraints - Room Bounding: yes; Height Offset From Level: 2600 mm; Level: Level: Level 2
Phasing - Phase Created: New Construction
Dimensions - Perimeter: 33000 mm; Area: 64.26 m2
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Roughness: 1; Absorptance: 0.1
