Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:39:38
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:39:38 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{371A9F38-CF7B-43BF-946A-C5DE253276ED}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:39:37 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:39:38 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:39:38 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Name: Project Name; Project Status: Project Status; Project Address: Enter address here; Project Number: Project Number; Project Issue Date: Issue Date; Client Name: Owner

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Graphics - Line Weight: 1; Symbol at End 1 Default: no; Color: 0; Line Pattern: Centre; Symbol: Level Head - FFL: Level Head - FFL; Symbol at End 2 Default: yes
Identity Data - Structural: no; Name: Level 2; Building Story: yes
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell Opal QAddressable Wall Sounder NFXI-WS-R, NFXI-WS-R:Notifier by Honeywell Opal QAddressable Wall Sounder NFXI-WS-R:209027
In: Level 2
Material: Plastic - Green Generic
Phasing - Phase Created: New Construction
Constraints - Host: Level : Level 2; Moves With Nearby Elements: no; Level: Level: Level 2; Offset: 0 mm
Identity Data - Mark: 7; OmniClass Title: Environmental Detection/Registration; URL: www.notifierfiresystems.co.uk; Manufacturer: Notifier by Honeywell; Assembly Description: Misc. Other Fire Protection Systems; Description: Opal Addressable Wall Sounder; Assembly Code: D4090900; Product Code: NFXI-WS-R; OmniClass Number: 23.85.30.21; Model: Wall Mounted Sounder
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell Opal QAddressable Wall Sounder NFXI-WS-R
Title Text - Fax No.: +44 (0) 1273 376894; Tel No.: +44 (0) 1273 897000; Email: sales@notifierfiresystems.co.uk; Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY, UK

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Constraints - Height Offset From Level: 2600 mm; Level: Level: Level 2; Room Bounding: yes
Phasing - Phase Created: New Construction
Dimensions - Area: 64.26 m2; Perimeter: 33000 mm
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Roughness: 1; Absorptance: 0.1
