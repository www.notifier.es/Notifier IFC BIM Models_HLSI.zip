Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:51:21
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:51:21 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{EEAA20DD-CF2B-4D0A-9B53-808EC4C2BA41}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:51:18 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:51:19 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:51:19 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Status: Project Status; Client Name: Owner; Project Address: Enter address here; Project Name: Project Name; Project Issue Date: Issue Date; Project Number: Project Number

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Graphics - Symbol at End 2 Default: no; Symbol at End 1 Default: yes; Line Weight: 1; Symbol: Level Head - Circle: Level Head - Circle; Line Pattern: Centre; Color: 0
Identity Data - Structural: no; Building Story: yes; Name: Level 0
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell FAAST Fire Alarm Aspiration Sensing Technology 8100E, 8100E:Notifier by Honeywell FAAST Fire Alarm Aspiration Sensing Technology 8100E:217748
In: Level 0
Material: Default, UHMW, Black, GFRP
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0; Offset: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell FAAST Fire Alarm Aspiration Sensing Technology 8100E
Title Text - Tel No.: +44 (0) 1273 897000; Email: sales@notifierfiresystems.co.uk; Fax No.: +44 (0) 1273 376894; Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY, UK
Identity Data - Manufacturer: Notifier by Honeywell; Model: FAAST Fire Alarm Aspiration Sensing Technology; Product Code: 8100E; URL: www.notifierfiresystems.co.uk; Description: Aspiring Sensing Technology ASD; Assembly Description: Misc. Other Fire Protection Systems; Assembly Code: D4090900
