Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T08:12:16
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 08:12:16 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{26AD5269-A160-4075-9103-7419B1A2B8F1}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 08:12:13 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 08:12:14 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 08:12:14 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Client Name: Owner; Project Number: Project Number; Project Status: Project Status; Project Name: Project Name; Project Issue Date: Issue Date; Project Address: Enter address here

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Symbol at End 1 Default: yes; Symbol at End 2 Default: no; Line Weight: 1; Symbol: Level Head - Circle: Level Head - Circle
Identity Data - Name: Level 0; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell SMART4 Multi-Criteria Fire Sensor IRX-751CTEM, IRX-751CTEM:Notifier by Honeywell SMART4 Multi-Criteria Fire Sensor IRX-751CTEM:218018
In: Level 0
Material: ALARM
Phasing - Phase Created: New Construction
Identity Data - Mark: 1; Model: SMART4 Multi-Criteria Fire Sensor; Description: Infrared, Carbon Monoxide, Optical and Thermal Multi Sensor; OmniClass Number: 23.85.30.21; OmniClass Title: Environmental Detection/Registration; Manufacturer: Notifier by Honeywell; Assembly Description: Misc. Other Fire Protection Systems; Assembly Code: D4090900; URL: www.notifierfiresystems.co.uk; Product Code: IRX-751CTEM-IV / W
Constraints - Elevation: 0 mm; Host: Level : Level 0; Default Elevation: 1200 mm
Other - Schedule Level: Level: Level 0
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell SMART4 Multi-Criteria Fire Sensor IRX-751CTEM
Title Text - Fax No.: +44 (0) 1273 376894; Email: sales@notifierfiresystems.co.uk; Tel No.: + 44 (0) 1273 897000; Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY

# IfcCovering: Compound Ceiling:Plain, Compound Ceiling:Plain:217094
In: Level 0
PredefinedType: CEILING; Material: Metal Stud Layer 45 mm, Gypsum Wall Board 12 mm
Constraints - Height Offset From Level: -57.4657 mm; Level: Level: Level 0; Room Bounding: yes
Dimensions - Volume: 9.07212 m3; Perimeter: 53000 mm; Area: 159.16 m2
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Plain; TotalThickness: 57 mm
Identity Data - Keynote: K40
Analytical Properties - Absorptance: 0.7; Thermal Resistance (R): 1.81846; Roughness: 3; Heat Transfer Coefficient (U): 0.549915; Thermal mass: 11142.2
Graphics - Coarse Scale Fill Color: 16777215
Construction - Thickness: 57 mm
