Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:30:15
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:30:15 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{D0AEAB69-7FD4-4956-A410-A5547338E414}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:30:14 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:30:15 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:30:15 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Status: Project Status; Client Name: Owner; Project Number: Project Number; Project Name: Project Name; Project Issue Date: Issue Date; Project Address: Enter address here

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Graphics - Color: 0; Symbol: Level Head - FFL: Level Head - FFL; Symbol at End 2 Default: yes; Line Weight: 1; Line Pattern: Centre; Symbol at End 1 Default: no
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 2
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell OPAL Photoelectric Smoke Detector NFXI-OPT, NFXI-SMT2:Notifier by Honeywell OPAL Photoelectric Smoke Detector NFXI-OPT:204732
In: Level 2
Material: ALARM
Phasing - Phase Created: New Construction
Identity Data - Mark: 2; Assembly Code: D4090900; Manufacturer: Notifier by Honeywell; Assembly Description: Misc. Other Fire Protection Systems; Product Code: NFXI-OPT; OmniClass Number: 23.85.30.21; Model: OPAL Optical Smoke Detector; URL: www.notifierfiresystems.co.uk; OmniClass Title: Environmental Detection/Registration; Description: Photoelectric Smoke Detector
Constraints - Offset: 0 mm; Level: Level: Level 2; Moves With Nearby Elements: no; Host: Level : Level 2
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell OPAL Photoelectric Smoke Detector NFXI-OPT
Title Text - Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY; Email: sales@notifierefiresystems.co.uk; Fax No.: +44 (0) 1273 376894; Tel No.: +44 (0) 1273 897000

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Dimensions - Perimeter: 33000 mm; Area: 64.26 m2
Constraints - Level: Level: Level 2; Room Bounding: yes; Height Offset From Level: 2600 mm
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Absorptance: 0.1; Roughness: 1
