Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:26:29
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:26:29 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{3BACA863-6F0D-4E64-8488-3AD2C9EB5DDD}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:26:28 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:26:28 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:26:28 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Number: Project Number; Project Status: Project Status; Project Name: Project Name; Project Address: Enter address here; Project Issue Date: Issue Date; Client Name: Owner

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Graphics - Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - FFL: Level Head - FFL; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Color: 0
Identity Data - Building Story: yes; Structural: no; Name: Level 2
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell Very Intelligent Early Warning HSSD Detector FSL-751E, FSL-751E:Notifier by Honeywell Very Intelligent Early Warning HSSD Detector FSL-751E:203911
In: Level 2
Material: Plastic - White Generic
Identity Data - Mark: 1; Assembly Description: Misc. Other Fire Protection Systems; OmniClass Number: 23.85.30.21; Model: VIEW High Sensitivity Smoke Detector; Description: High Sensitivity Smoke Detector; Product Code: FSL-751E; OmniClass Title: Environmental Detection/Registration; Type Comments: Smoke Detector; Assembly Code: D4090900; URL: www.notifierfiresystems.co.uk; Manufacturer: Notifier by Honeywell
Constraints - Level: Level: Level 2; Offset: 0 mm; Host: Level : Level 2; Moves With Nearby Elements: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell Very Intelligent Early Warning HSSD Detector FSL-751E
Title Text - Tel No.: +44 (0) 1273 897000; Fax No.: +44 (0) 1273 376894; Email: sales@notifierfiresystems.co.uk; Address line 1: Caburn House, Brooks road, Lewes, E. Sussex BN7 2BY

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Dimensions - Perimeter: 33000 mm; Area: 64.26 m2
Constraints - Room Bounding: yes; Level: Level: Level 2; Height Offset From Level: 2600 mm
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Absorptance: 0.1; Roughness: 1
