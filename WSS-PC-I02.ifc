Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:38:43
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:38:43 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{3847EB37-C7D4-42E3-83BB-0B6DD183A479}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:38:42 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:38:42 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:38:43 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Name: Project Name; Client Name: Owner; Project Number: Project Number; Project Status: Project Status; Project Issue Date: Issue Date; Project Address: Enter address here

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Graphics - Symbol at End 1 Default: no; Color: 0; Line Pattern: Centre; Symbol at End 2 Default: yes; Line Weight: 1; Symbol: Level Head - FFL: Level Head - FFL
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 2

# IfcBuildingElementProxy: Notifier by Honeywell Opal QAddressable Wall Sounder NFXI-WSF-WC, NFXI-WSF-WC:Notifier by Honeywell Opal QAddressable Wall Sounder NFXI-WSF-WC:208137
In: Level 2
Material: Plastic - Green Generic, Plastic - Clear Generic
Constraints - Moves With Nearby Elements: no; Level: Level: Level 2; Offset: 0 mm; Host: Level : Level 2
Identity Data - Mark: 6; Assembly Description: Misc. Other Fire Protection Systems; Description: Opal Addressable Wall Sounder / Beacon; OmniClass Number: 23.85.30.21; URL: www.notifierfiresystems.co.uk; Assembly Code: D4090900; Product Code: NFXI-WSF-WC; Model: Wall Mounted Sounder /Beacon; Manufacturer: Notifier by Honeywell; OmniClass Title: Environmental Detection/Registration
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell Opal QAddressable Wall Sounder NFXI-WSF-WC
Title Text - Tel No.: +44 (0) 1273 897000; Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY, UK; Email: sales@notifierfiresystems.co.uk; Fax No.: +44 (0) 1273 376894

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Constraints - Level: Level: Level 2; Height Offset From Level: 2600 mm; Room Bounding: yes
Dimensions - Perimeter: 33000 mm; Area: 64.26 m2
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Absorptance: 0.1; Roughness: 1
