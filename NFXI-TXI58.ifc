Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2014-10-31T10:36:28
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 31 10:36:28 2014 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{4E5B3BDB-98CB-40E7-86A4-55DFA102BF86}\ifc * Database version: 5507 * Database creation date: Fri Oct 31 10:36:27 2014 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 31 10:36:28 2014 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 31 10:36:28 2014 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Name: Project Name; Project Address: Enter address here; Client Name: Owner; Project Number: Project Number; Project Status: Project Status; Project Issue Date: Issue Date

# IfcBuildingStorey, Level 2
LongName: Level 2; Elevation: 3000 mm
Graphics - Line Pattern: Centre; Color: 0; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Symbol: Level Head - FFL: Level Head - FFL
Constraints - Elevation Base: Project Base Point; Elevation: 3000 mm
Identity Data - Building Story: yes; Name: Level 2; Structural: no
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Notifier by Honeywell OPAL Thermal Sensor NFXI-TDIFF, NFXI-TFIX58, NFXI-TFIX78, NFXI-TXI58:Notifier by Honeywell OPAL Thermal Sensor NFXI-TDIFF, NFXI-TFIX58, NFXI-TFIX78:206351
In: Level 2
Material: ALARM
Identity Data - Mark: 4; Assembly Description: Misc. Other Fire Protection Systems; Model: OPAL Thermal Sensor; Product Code: NFXI-TDIFF, NFXI-TFIX58,NFXI-TFIX78; Assembly Code: D4090900; OmniClass Number: 23.85.30.21; URL: www.notifierfiresystems.co.uk; OmniClass Title: Environmental Detection/Registration; Description: Thermal Sensor; Manufacturer: Notifier by Honeywell
Constraints - Moves With Nearby Elements: no; Host: Level : Level 2; Offset: 0 mm; Level: Level: Level 2
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Notifier by Honeywell
Pset_BuildingElementProxyCommon - Reference: Notifier by Honeywell OPAL Thermal Sensor NFXI-TDIFF, NFXI-TFIX58, NFXI-TFIX78
Title Text - Address line 1: Caburn House, Brooks Road, Lewes, E. Sussex BN7 2BY; Fax No.: +44 (0) 1273 376894; Tel No.: +44 (0) 1273 897000; Email: sales@notifierefiresystems.co.uk

# IfcCovering: Basic Ceiling:Ceiling 1, Basic Ceiling:Ceiling 1:202966
In: Level 2
PredefinedType: CEILING
Dimensions - Perimeter: 33000 mm; Area: 64.26 m2
Constraints - Room Bounding: yes; Level: Level: Level 2; Height Offset From Level: 2600 mm
Phasing - Phase Created: New Construction
Pset_CoveringCommon - Reference: Ceiling 1
Analytical Properties - Roughness: 1; Absorptance: 0.1
